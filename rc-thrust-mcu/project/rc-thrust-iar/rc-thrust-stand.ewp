# IAR project rc-thrust-stand.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\..\library\CMSIS\Device\ST\STM32F1xx\Include; ..\..\library\CMSIS\Core\Include; ..\..\library\STM32F1xx_HAL_Driver\Inc; ..\..\source; ..\..\source\driver; ..\..\source\driver\ILI9341; ..\..\source\lcd_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: rc-thrust-stand.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ../../source/: global.h lcd_lib_config.h main.cpp startup_stm32f103xb.s stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c stm32f1xx_it.c utils.c utils.h
  group driver/ILI9341
    ../../source/driver/ILI9341/: ILI9341.c ILI9341.h ILI9341_STM32_SPI.c ILI9341_STM32_SPI.h
  group lcd_lib
    ../../source/lcd_lib/: lcd_font_12x16_mono.c lcd_font_6x8_mono.c lcd_font_h10.c lcd_font_h10_bold.c lcd_font_h12.c lcd_font_h32.c lcd_font_h48.c lcd_font_typedef.h lcd_lib.c lcd_lib.h lcd_lib_font.c lcd_lib_graph.c lcd_lib_private.h
  group lcd_lib/portable
    ../../source/lcd_lib/portable/: lcd_lib_graph_ILI9341.c
  group library/CMSIS
    ../../../../library/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group library/STM32F1xx_HAL_Driver
    ../../library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
